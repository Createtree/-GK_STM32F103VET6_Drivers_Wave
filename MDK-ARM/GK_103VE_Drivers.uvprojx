# Keil uVision project GK_103VE_Drivers.uvprojx, settings and files
target GK_103VE_Drivers (5060960::V5.06 update 7 (build 960)::.\ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.3.0
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x807FFFF)  CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: GK_103VE_Drivers +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32F103xE
  c misc: --locale=english
  c include: ../Inc;                                                           ../Drivers/STM32F1xx_HAL_Driver/Inc/Legacy;                                                           ../Drivers/STM32F1xx_HAL_Driver/Inc;                                                           ../Middlewares/Third_Party/FreeRTOS/Source/include;                                                           ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS;                                                           ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3;                                                           ../Drivers/CMSIS/Device/ST/STM32F1xx/Include;                                                           ../Drivers/CMSIS/Include;                                                           ..\WS-Drivers;                                                           ..\WSOS;                                                         ../Middlewares/Third_Party/FatFs/src;                                                        ../Middlewares/ST/STM32_USB_Device_Library/Core/Inc;                                                        ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Inc;                                        ../Middlewares/Third_Party/FatFs/src/drivers
  asm include: ..\Inc
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group Application/MDK-ARM
    ./: startup_stm32f103xe.s
  group WSOS
    ../WSOS/: kernel.c
  group WS/Drivers
    ../WS-Drivers/: ws_borad_base.c ws_core.c ws_task.c ws_w25qxx.c ws_ili9xxx.c ws_config.c ws_capture.c wareform.c
  group Application/User
    ../Src/: main.c freertos.c bsp_driver_sd.c fatfs.c user_diskio.c usb_device.c usbd_conf.c usbd_desc.c usbd_storage_if.c stm32f1xx_it.c stm32f1xx_hal_msp.c stm32f1xx_hal_timebase_tim.c
  group Drivers/STM32F1xx_HAL_Driver
    ../Drivers/STM32F1xx_HAL_Driver/Src/: stm32f1xx_hal_gpio_ex.c stm32f1xx_hal_pcd.c stm32f1xx_hal_pcd_ex.c stm32f1xx_ll_usb.c stm32f1xx_hal.c stm32f1xx_hal_rcc.c stm32f1xx_hal_rcc_ex.c stm32f1xx_hal_gpio.c stm32f1xx_hal_dma.c stm32f1xx_hal_cortex.c stm32f1xx_hal_pwr.c stm32f1xx_hal_flash.c stm32f1xx_hal_flash_ex.c stm32f1xx_hal_exti.c stm32f1xx_hal_adc.c stm32f1xx_hal_adc_ex.c stm32f1xx_ll_fsmc.c stm32f1xx_hal_sram.c stm32f1xx_hal_rtc.c stm32f1xx_hal_rtc_ex.c stm32f1xx_ll_sdmmc.c stm32f1xx_hal_sd.c stm32f1xx_hal_spi.c stm32f1xx_hal_tim.c stm32f1xx_hal_tim_ex.c stm32f1xx_hal_uart.c
  group Drivers/CMSIS
    ../Src/: system_stm32f1xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS/: cmsis_os.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM3/: port.c
  group Middlewares/FatFs
    ../Middlewares/Third_Party/FatFs/src/: diskio.c ff.c ff_gen_drv.c
    ../Middlewares/Third_Party/FatFs/src/option/: syscall.c ccsbcs.c
    ../Middlewares/Third_Party/FatFs/src/drivers/: sd_diskio.c
  group Middlewares/USB_Device_Library
    ../Middlewares/ST/STM32_USB_Device_Library/Core/Src/: usbd_core.c usbd_ctlreq.c usbd_ioreq.c
    ../Middlewares/ST/STM32_USB_Device_Library/Class/MSC/Src/: usbd_msc.c usbd_msc_bot.c usbd_msc_data.c usbd_msc_scsi.c
software components: CMSIS:CORE 4.3.0
